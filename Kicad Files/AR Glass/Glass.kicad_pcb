# Repository jadoo-tech/Exoskeleton_public (continued)

## KiCad design Kicad Files/EEG/Channel/Channel.kicad_pcb

Board: 2 copper layers, 74.9 x 20.3 mm, 28 parts (1 on the bottom side), 25 nets.

Parts:
C1, C2, C3, C4, C8: 1uF; C_0805_2012Metric
C5, C6, C7: 0.22uF; C_0603_1608Metric
J1: Conn_01x02_Pin; PinHeader_1x02_P2.00mm_Vertical
J2: Conn_01x07_Pin; GoldFingers_1x07_P2.50mm
R1, R6, R10: 1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R2, R4: 2640; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 1320; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5, R9: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7, R8, R11: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12: 150k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
U1: INA823; VSSOP-8_3x3mm_P0.65mm
U2, U3, U4, U5: LF356N; SOIC127P599X175-8N
U6: MCP4161; DIP-8_W7.62mm_Socket

Connections:
CKL: J2.5, U6.2 (SCK)
CS: J2.6, U6.1 (~CS)
Electrode: J1.1, U1.3 (+)
GND: C5.2, C7.2, J2.7, R6.2, R10.2, R12.2, U1.5 (Ref), U6.4 (V_{SS}), U6.5 (P0A)
unnamed: C1.1, R2.2, U1.6
unnamed: C1.2, C4.1, R3.1
unnamed: C2.1, C3.1, R2.1, R4.2
unnamed: C6.1, R9.1, R11.1, U4.6
unnamed: C6.2, R7.2, R8.1
unnamed: R1.1, U1.1 (Rg)
unnamed: R1.2, U1.8 (Rg)
unnamed: R5.2, R6.1, U2.3 (+)
unnamed: C2.2, C3.2, R3.2, U2.2 (-), U2.6
unnamed: C4.2, R4.1, U3.3 (+)
unnamed: R5.1, R7.1, U3.2 (-), U3.6
unnamed: C5.1, R8.2, U4.3 (+)
unnamed: R9.2, R10.1, U4.2 (-)
unnamed: C7.1, R11.2, U5.3 (+)
unnamed: U5.2 (-), U6.7 (P0B)
unnamed: C8.1, U5.6, U6.6 (P0W)
Out: C8.2, J2.1, R12.1
Ref_Electrode: J1.2, U1.2 (-)
SDI: J2.4, U6.3 (SDI/SDO)
Vdd: J2.3, U1.7 (V+), U2.7 (V+), U3.7 (V+), U4.7 (V+), U5.7 (V+), U6.8 (V_{DD})
Vss: J2.2, U1.4 (V-), U2.4 (V-), U3.4 (V-), U4.4 (V-), U5.4 (V-)

## Commit log

2024-08-28 working base
2024-09-06 Displaying video to monitor from client camera added
2024-09-06 Send video data to server pi without web
2024-09-23 EEG Files from August
2024-09-24 Video half working
    timeout = 300, so 5 min of camera display in gunicorn.config.py
2024-10-15 PCB files — Previous EEG Uploaded
2024-10-15 Final demo PCB with AR Glass Pins Corrected
2024-10-15 Limbs & Motherboard Circuit uploaded —Needs update
2024-10-19 Rearranged
2024-10-19 Rearrange EEG directory
2024-10-19 EEG Updated
2024-10-19 Schematic Errors Fixed, some footprints done
2024-11-01 Add files via upload
    Redo the circuit with waqas's insisted potentiometer and added BOM
2024-11-18 Rearrangement
2024-11-18 EEG new PCB done
2024-11-18 Gerber generated
2024-11-20 heating_circuit rough draft completed
2024-11-20 Added silkscreen and mounting holes
2024-11-20 Minor schematic changes
2024-11-20 AR revised
2024-11-20 AR changed
2024-11-20 Motor moved
2024-11-20 Added ground plane
2024-11-20 some more movements
2024-11-20 Heater Checked
2024-11-20 Fixed schematics
2024-11-20 fixed save file
2024-11-21 EEG Power Updated
2024-11-21 Renamed
2024-12-05 Corrections in EEG
2024-12-05 Working on EEG
2024-12-08 Fixed PWM direction, rerouted PCB trades
2024-12-08 EEG Done and some rearrangements
2024-12-08 AR modified
2024-12-19 AR & EEG corrected
2025-01-31 work
2025-01-31 work..
2025-02-01 EEG done
2025-02-16 Fixed heating circuit track width
2025-02-16 added thicker traces for heater power
2025-03-03 updates?
2025-03-08 adding gyroscope
2025-03-08 Renamed File
2025-03-09 Papers
2025-03-09 Renamed folder (contained illegal characters)
2025-03-09 Moved files
2025-03-09 Added gyroscope
2025-03-09 Added BOM
2025-03-09 Updated BOM
2025-03-16 limb circuit updates
2025-03-16 Finished limb circuit board
2025-05-25 Update instructions
2025-05-25 Updated debugging instructions
2025-06-09 some changes
2025-06-29 Video Display Test
2025-06-29 Video Display Test -- Some errors fixed
2025-09-09 Last Update for 2025 (Server)
2025-09-09 Revert "Last Update for 2025 (Server)"
    This reverts commit c78feff2333a2c4fa5fcf5af88a9c686a0c6de23.
2025-09-09 Control Files Update
2025-09-09 Kicad & Microcontroller Restored
2026-02-07 llm archeology and an attmpted reconstruction of python deps
2026-02-07 Add local integration harness and client simulation mode
2026-02-07 readme note
2026-02-07 Refactor runtime comms to v2 session protocol
    Replace legacy socket pairing with a connection manager and new client agent so multi-client routing is identity-based and observable. Update repo docs and local run/test paths to reflect the active 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
2026-02-07 Add exo dashboard and per-client control pages
    Introduce a connected-client dashboard with single-client tabs for live video, controls, and command history so operators can target each session directly. Update local macOS startup to run two simul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
2026-02-07 mark legacy files and show text in simulated video
2026-06-13 docs: redirect to unified_server
