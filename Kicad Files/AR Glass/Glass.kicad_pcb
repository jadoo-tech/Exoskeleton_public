# Repository jadoo-tech/Exoskeleton_public

File README.md:

# This project has moved

Development continues in **[jadoo-tech/unified_server](https://github.com/jadoo-tech/unified_server)**.

Contact **Dr. Waqas Khalid** for GitHub access.

## KiCad design Kicad Files/AR Glass/Glass.kicad_pcb

File Kicad Files/Readme.md:

** 'EEG Circuits' folder contains the old files by Yena, 'EEG kicad' contains updated files from August **

Parts:
J1, J4: OLED1; Molex_54548-1071_1x10-1MP_P0.5mm_Horizontal
J2, J5: OLED2; Molex_54548-1071_1x10-1MP_P0.5mm_Horizontal
J3: Camera1; Molex_54548-1071_1x10-1MP_P0.5mm_Horizontal
J6: Camera2; Molex_54548-1071_1x10-1MP_P0.5mm_Horizontal
TP1, TP2, TP3, TP4, TP5, TP6: TestPoint; PinHeader_1x01_P2.54mm_Vertical
U1: Pico; RPi_Pico_SMD_TH

Connections:
3.3V: J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, TP2.1, TP4.1, TP6.1, U1.36 (3V3)
CLK_LED: J1.4, J2.4, J4.4, J5.4, U1.4 (GPIO2)
CS_LED1: J1.5, J4.5, U1.17 (GPIO13)
CS_LED2: J2.5, J5.5, U1.7 (GPIO5)
DC_LED1: J1.6, J4.6, U1.20 (GPIO15)
DC_LED2: J2.6, J5.6, U1.10 (GPIO7)
DIN_LED: J1.3, J2.3, J4.3, J5.3, U1.5 (GPIO3)
DO_Cam1: J3.7, U1.14 (GPIO10)
DO_Cam2: J6.7, U1.16 (GPIO12)
GND: J1.2, J2.2, J3.8, J4.2, J5.2, J6.8, TP1.1, TP3.1, TP5.1, U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.33 (AGND), U1.38 (GND), U1.42 (GND)
HREF_Cam1: J3.5, U1.25 (GPIO19)
HREF_Cam2: J6.5, U1.12 (GPIO9)
PCLK_Cam1: J3.6, U1.24 (GPIO18)
PCLK_Cam2: J6.6, U1.15 (GPIO11)
RST_LED1: J1.7, J4.7, U1.19 (GPIO14)
RST_LED2: J2.7, J5.7, U1.9 (GPIO6)
SCL_Cam: J3.2, J6.2, U1.27 (GPIO21)
SDA_Cam1: J3.3, U1.26 (GPIO20)
SDA_Cam2: J6.3, U1.6 (GPIO4)
VSYNC_Cam1: J3.4, U1.21 (GPIO16)
VSYNC_Cam2: J6.4, U1.11 (GPIO8)

Board: 2 copper layers, 72.4 x 31.7 mm, 13 parts (0 on the bottom side), 21 nets.

## KiCad design Kicad Files/Limb Circuit/Limb_Circuit.kicad_pcb

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
C1, C2: 0.1uF; C_0402_1005Metric
J1: XT60_F_16.6V; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J2: XT60_F_Heater; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J3: XT60_F_Thermocouple; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
Q1: BUK9M52-40EX; LFPAK33
R1: 100; R_0805_2012Metric
R2: 10k; R_0805_2012Metric
U1: MAX31855KASA+T; 21-0041B_8_MXM
U2: LSM6DSL; LGA-14_3x2.5mm_P0.5mm_LayoutBorder3x4y

Connections:
3.3V_ard: A1.17 (3V3), C1.1, U1.4 (VCC), U2.1 (SDO/SA0), U2.5 (VDDIO), U2.12 (CS)
+16.4V: J1.2, J2.2
CLK: A1.16 (D13), U1.5 (SCK)
CS_thermocouple: A1.14 (D11), U1.6 (*CS)
GND_16.4V: A1.4 (GND), A1.29 (GND), C1.2, C2.2, J1.1, Q1.1 (S), Q1.2 (S), Q1.3 (S), R2.2, U1.1 (GND), U2.6 (GND), U2.7 (GND)
GND_heater: J2.1, Q1.5 (D)
MISO_thermocouple: A1.15 (D12), U1.7 (SO)
unnamed: J3.1, U1.3 (T+)
unnamed: J3.2, U1.2 (T-)
unnamed: Q1.4 (G), R1.2, R2.1
unnamed: C2.1, U2.8 (VDD)
PWM_heater: A1.13 (D10), R1.1
SCL_gyro: A1.24 (A5), U2.13 (SCL)
SDA_gyro: A1.23 (A4), U2.14 (SDA)

Board: 2 copper layers, 56.5 x 56.0 mm, 11 parts (0 on the bottom side), 14 nets.

File Kicad Files/Heater/Exoskeleton BOM - Limb Circuit.csv:

# of Boards,1,EXOSKELETON BILL OF MATERIALS / DATASHEETS,,,,,,,Total Price ($),40.34,
Mouser Part#/SKU,,Manufacturer Part #,Digi-key Part#/SKU,Description,Datasheet Link,Purchase URL,Qty,Min Qty,Price/unit ($),Total Price ($),Note (+ Please briefly explain you choose this component)
SMD,,,,,,,,,,,
R1,,RMCF0805FT100R,RMCF0805FT100RCT-ND,"100 Ohms ±1% 0.125W, 1/8W Chip Resistor 0805 (2012 Metric) Automotive AEC-Q200 Thick Film",https://www.seielect.com/catalog/sei-rmcf_rmcp.pdf,https://www.digikey.com/en/products/detail/stackpole-electro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,1,1,0.1,0.1,
R2,,RMCF0805FT10K0,RMCF0805FT10K0CT-ND,"10 kOhms ±1% 0.125W, 1/8W Chip Resistor 0805 (2012 Metric) Automotive AEC-Q200 Thick Film",https://www.seielect.com/catalog/sei-rmcf_rmcp.pdf,https://www.digikey.com/en/products/detail/stackpole-electro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,1,1,0.1,0.1,
U1,,MAX31855KASA+T,MAX31855KASA+TCT-ND,IC CONV THERMOCOUPLE-DGTL SOIC,https://www.analog.com/media/en/technical-documentation/data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,https://www.digikey.com/en/products/detail/analog-devices-in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,1,1,10.85,10.85,
Q1,,BUK9M52-40EX,1727-7317-1-ND,N-Channel 40 V 17.6A (Tj) 31W Surface Mount LFPAK33,https://assets.nexperia.com/documents/data-sheet/BUK9M52-40E.pdf,https://www.digikey.com/en/products/detail/nexperia-usa-inc/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,1,1,0.75,0.75,
U2,,LSM6DSLTR,497-16705-1-ND,IMU ACCEL/GYRO I2C/SPI 14LGA,https://www.st.com/content/ccc/resource/technical/document/d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,https://www.digikey.com/en/products/detail/stmicroelectronic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,1,1,4.36,4.36,
"C1, C2",,CL05B104KP5NNNC,1276-1002-1-ND,CAP CER 0.1UF 10V X7R 0402,https://mm.digikey.com/Volume0/opasdata/d220001/medias/docus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,https://www.digikey.com/en/products/detail/samsung-electro-m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,2,1,0.08,0.16,
,,,,,,,,,,,
Through-Hole Components,,,,,,,,,,,
J1-J3,,XT60 F Horizontal,,Connectors for power/peltier/thermocouple,https://www.jameco.com/Jameco/Products/ProdDS/2338287.pdf,https://www.jameco.com/z/XT60H-F-Amass-XT60-Female-Bullet-Co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,3,1,0.95,2.85,
A1,,Arduino_Nano_v3.x,,Arduino Nano,https://docs.arduino.cc/resources/datasheets/A000005-datasheet.pdf,https://store-usa.arduino.cc/products/arduino-nano,1,1,21.17,21.17,

## KiCad design Kicad Files/EEG kicad/EEG2.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C61, C62, C63, C64, C65, C66, C67, C68, C69, C70, C71, C72, C73, C74, C75, C76, C77, C78, C79, C80: 1uF; C_0805_2012Metric
C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C46, C47, C48, C49, C50, C51, C52, C53, C54, C55, C56, C57, C58, C59, C60: 0.22uF; C_0603_1608Metric
J1: Conn_02x20_Top_Bottom; GoldFingers_1x40_0.155mm_DoubleSided
J2: Conn_01x04_Pin; PinHeader_1x04_P1.27mm_Vertical
R1, R2, R3, R4, R5, R22, R24, R26, R29, R32, R41, R42, R43, R44, R45, R46, R47, R48, R50, R51, R80, R81, R83, R84, R85, R86, R87, R88, R89, R90, R99, R102, R105, R107, R109, R126, R127, R128, R129, R130: 1k; R_0402_1005Metric
R6, R7, R8, R10, R12, R16, R17, R18, R19, R20, R111, R112, R113, R114, R115, R119, R121, R123, R124, R125: 2.64k; R_0603_1608Metric
R9, R11, R13, R14, R15, R116, R117, R118, R120, R122: 1.32k; R_0805_2012Metric
R21, R23, R25, R28, R31, R100, R103, R106, R108, R110: 100; R_0805_2012Metric
R27, R30, R33, R34, R35, R36, R37, R38, R39, R40, R49, R52, R53, R54, R55, R76, R77, R78, R79, R82, R91, R92, R93, R94, R95, R96, R97, R98, R101, R104: 10k; R_0603_1608Metric
R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72, R73, R74, R75: 150k; R_0402_1005Metric
U1, U2, U3, U4, U5, U57, U58, U59, U60, U61: INA823; VSSOP-8_3x3mm_P0.65mm
U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16, U17, U18, U19, U20, U21, U22, U23, U24, U25, U37, U38, U39, U40, U41, U42, U43, U44, U45, U46, U47, U48, U49, U50, U51, U52, U53, U54, U55, U56: LF356M; SOIC127P599X175-8N
U26, U27, U28, U29, U30, U32, U33, U34, U35, U36: AD5293
U31: Teensy4.1; Teensy41

Connections:
CLK: U26.11 (CLK), U27.11 (CLK), U28.11 (CLK), U29.11 (CLK), U30.11 (CLK), U31.35 (13_SCK_LED), U32.11 (CLK), U33.11 (CLK), U34.11 (CLK), U35.11 (CLK), U36.11 (CLK)
CS 1: U26.12 (~CS), U31.14 (12_MISO_MQSL)
CS 2: U27.12 (~CS), U31.12 (10_CS_MQSR)
CS 3: U28.12 (~CS), U31.11 (9_OUT1C)
CS 4: U29.12 (~CS), U31.10 (8_TX2_IN1)
CS 5: U30.12 (~CS), U31.9 (7_RX2_OUT1A)
CS 6: U31.8 (6_OUT1D), U32.12 (~CS)
CS 7: U31.7 (5_IN2), U33.12 (~CS)
CS 8: U31.6 (4_BCLK2), U34.12 (~CS)
CS 9: U31.5 (3_LRCLK2), U35.12 (~CS)
CS 10: U31.4 (2_OUT2), U36.12 (~CS)
Electrode1: J1.1, U1.3 (+)
Electrode2: J1.3, U2.3 (+)
Electrode3: J1.5, U3.3 (+)
Electrode4: J1.7, U4.3 (+)
Electrode5: J1.9, U5.3 (+)
Electrode6: J1.12, U57.3 (+)
Electrode7: J1.14, U58.3 (+)
Electrode8: J1.16, U59.3 (+)
Electrode9: J1.18, U60.3 (+)
Electrode10: J1.20, U61.3 (+)
Electrode Output 1: C36.2, R61.1, U31.36 (14_A0_TX3_SPDIF_OUT)
Electrode Output 2: C37.2, R62.1, U31.37 (15_A1_RX3_SPDIF_IN)
Electrode Output 3: C38.2, R63.1, U31.38 (16_A2_RX4_SCL1)
Electrode Output 4: C39.2, R64.1, U31.39 (17_A3_TX4_SDA1)
Electrode Output 5: C40.2, R65.1, U31.40 (18_A4_SDA)
Electrode Output 6: C41.2, R66.1, U31.41 (19_A5_SCL)
Electrode Output 7: C42.2, R67.1, U31.42 (20_A6_TX5_LRCLK1)
Electrode Output 8: C43.2, R68.1, U31.43 (21_A7_RX5_BCLK1)
Electrode Output 9: C44.2, R69.1, U31.44 (22_A8_CTX1)
Electrode Output 10: C45.2, R70.1, U31.45 (23_A9_CRX1_MCLK1)
GND: C21.2, C22.2, C24.2, C26.2, C28.2, C31.2, C32.2, C33.2, C34.2, C35.2, C46.2, C47.2, C48.2, C49.2, C50.2, C53.2, C55.2, C57.2, C59.2, C60.2, J2.4, R22.2, R24.2, R26.2, R29.2, R32.2, R42.2, R44.2, R46.2, R48.2, R51.2, R61.2, R62.2, R63.2, R64.2, R65.2, R66.2, R67.2, R68.2, R69.2, R70.2, R80.2, R83.2, R85.2, R87.2, R89.2, R99.2, R102.2, R105.2, R107.2, R109.2, U1.4 (V-), U1.5 (Ref), U2.4 (V-), U2.5 (Ref), U3.4 (V-), U3.5 (Ref), U4.4 (V-), U4.5 (Ref), U5.4 (V-), U5.5 (Ref), U6.4 (V-), U7.4 (V-), U8.4 (V-), U9.4 (V-), U10.4 (V-), U11.4 (V-), U12.4 (V-), U13.4 (V-), U14.4 (V-), U15.4 (V-), U16.4 (V-), U17.4 (V-), U18.4 (V-), U19.4 (V-), U20.4 (V-), U21.4 (V-), U22.4 (V-), U23.4 (V-), U24.4 (V-), U25.4 (V-), U26.2 (Vss-), U26.5 (RL), U26.9 (GND), U27.2 (Vss-), U27.5 (RL), U27.9 (GND), U28.2 (Vss-), U28.5 (RL), U28.9 (GND), U29.2 (Vss-), U29.5 (RL), U29.9 (GND), U30.2 (Vss-), U30.5 (RL), U30.9 (GND), U32.2 (Vss-), U32.5 (RL), U32.9 (GND), U33.2 (Vss-), U33.5 (RL), U33.9 (GND), U34.2 (Vss-), U34.5 (RL), U34.9 (GND), U35.2 (Vss-), U35.5 (RL), U35.9 (GND), U36.2 (Vss-), U36.5 (RL), U36.9 (GND), U37.4 (V-), U38.4 (V-), U39.4 (V-), U40.4 (V-), U41.4 (V-), U42.4 (V-), U43.4 (V-), U44.4 (V-), U45.4 (V-), U46.4 (V-), U47.4 (V-), U48.4 (V-), U49.4 (V-), U50.4 (V-), U51.4 (V-), U52.4 (V-), U53.4 (V-), U54.4 (V-), U55.4 (V-), U56.4 (V-), U57.4 (V-), U57.5 (Ref), U58.4 (V-), U58.5 (Ref), U59.4 (V-), U59.5 (Ref), U60.4 (V-), U60.5 (Ref), U61.4 (V-), U61.5 (Ref)
GPIO14_TXD0: J2.2, U31.26 (34_RX8)
GPIO15_RXD0: J2.1, U31.27 (35_TX8)
unnamed: C1.1, R6.2, U1.6
unnamed: C1.2, C13.1, R9.1
unnamed: C2.1, R7.2, U2.6
unnamed: C3.1, R8.2, U3.6
unnamed: C4.1, R10.2, U4.6
unnamed: C5.1, R12.2, U5.6
unnamed: C6.2, C10.2, R6.1, R16.2
unnamed: C11.2, C18.2, R12.1, R20.2
unnamed: C7.2, C12.2, R7.1, R17.2
unnamed: C8.2, C14.2, R8.1, R18.2
unnamed: C2.2, C15.1, R11.1
unnamed: C9.2, C16.2, R10.1, R19.2
unnamed: C3.2, C17.1, R13.1
unnamed: C4.2, C19.1, R14.1
unnamed: C5.2, C20.1, R15.1
unnamed: C23.1, R41.1, R49.1, U16.6
unnamed: C23.2, R27.2, R36.1
unnamed: C25.1, R43.1, R52.1, U17.6
unnamed: C25.2, R30.2, R37.1
unnamed: C27.1, R45.1, R53.1, U18.6
unnamed: C27.2, R33.2, R38.1
unnamed: C29.1, R47.1, R54.1, U19.6
unnamed: C29.2, R34.2, R39.1
unnamed: C30.1, R50.1, R55.1, U20.6
unnamed: C30.2, R35.2, R40.1
unnamed: C36.1, R56.2, U21.6
unnamed: C37.1, R57.2, U22.6
unnamed: C38.1, R58.2, U23.6
unnamed: C39.1, R59.2, U24.6
unnamed: C40.1, R60.2, U25.6
unnamed: C41.1, R71.2, U37.6
unnamed: C42.1, R72.2, U38.6
unnamed: C43.1, R73.2, U39.6
unnamed: C44.1, R74.2, U40.6
unnamed: C45.1, R75.2, U41.6
unnamed: C51.1, R76.1, R81.1, U42.6
unnamed: C51.2, R91.1, R96.2
unnamed: C52.1, R77.1, R84.1, U43.6
unnamed: C52.2, R92.1, R97.2
unnamed: C54.1, R78.1, R86.1, U44.6
unnamed: C54.2, R93.1, R98.2
unnamed: C56.1, R79.1, R88.1, U45.6
unnamed: C56.2, R94.1, R101.2
unnamed: C58.1, R82.1, R90.1, U46.6
unnamed: C58.2, R95.1, R104.2
unnamed: C61.1, C76.2, R116.1
unnamed: C62.1, C77.2, R117.1
unnamed: C63.1, C70.1, R111.2, R119.1
unnamed: C64.1, C78.2, R118.1
unnamed: C65.1, C72.1, R112.2, R121.1
unnamed: C66.1, C79.2, R120.1
unnamed: C67.1, C73.1, R113.2, R123.1
unnamed: C68.1, C80.2, R122.1
unnamed: C69.1, C74.1, R114.2, R124.1
unnamed: C71.1, C75.1, R115.2, R125.1
unnamed: C76.1, R119.2, U57.6
unnamed: C77.1, R121.2, U58.6
unnamed: C78.1, R123.2, U59.6
unnamed: C79.1, R124.2, U60.6
unnamed: C80.1, R125.2, U61.6
unnamed: R1.1, U1.1 (Rg)
unnamed: R1.2, U1.8 (Rg)
unnamed: R2.1, U2.1 (Rg)
unnamed: R2.2, U2.8 (Rg)
unnamed: R3.1, U3.1 (Rg)
unnamed: R3.2, U3.8 (Rg)
unnamed: R4.1, U4.1 (Rg)
unnamed: R4.2, U4.8 (Rg)
unnamed: R5.1, U5.1 (Rg)
unnamed: R5.2, U5.8 (Rg)
unnamed: R126.1, U57.1 (Rg)
unnamed: R126.2, U57.8 (Rg)
unnamed: R127.1, U58.1 (Rg)
unnamed: R127.2, U58.8 (Rg)
unnamed: R128.1, U59.1 (Rg)
unnamed: R128.2, U59.8 (Rg)
unnamed: R129.1, U60.1 (Rg)
unnamed: R129.2, U60.8 (Rg)
unnamed: R130.1, U61.1 (Rg)
unnamed: R130.2, U61.8 (Rg)
unnamed: R21.2, R22.1, U6.3 (+)
unnamed: C6.1, C10.1, R9.2, U6.2 (-), U6.6
unnamed: C13.2, R16.1, U7.3 (+)
unnamed: R21.1, R27.1, U7.2 (-), U7.6
unnamed: R23.2, R24.1, U8.3 (+)
unnamed: C7.1, C12.1, R11.2, U8.2 (-), U8.6
unnamed: C15.2, R17.1, U9.3 (+)
unnamed: R23.1, R30.1, U9.2 (-), U9.6
unnamed: R25.2, R26.1, U10.3 (+)
unnamed: C8.1, C14.1, R13.2, U10.2 (-), U10.6
unnamed: C17.2, R18.1, U11.3 (+)
unnamed: R25.1, R33.1, U11.2 (-), U11.6
unnamed: R28.2, R29.1, U12.3 (+)
unnamed: C9.1, C16.1, R14.2, U12.2 (-), U12.6
unnamed: C19.2, R19.1, U13.3 (+)
unnamed: R28.1, R34.1, U13.2 (-), U13.6
unnamed: R31.2, R32.1, U14.3 (+)
unnamed: C11.1, C18.1, R15.2, U14.2 (-), U14.6
unnamed: C20.2, R20.1, U15.3 (+)
unnamed: R31.1, R35.1, U15.2 (-), U15.6
unnamed: C21.1, R36.2, U16.3 (+)
unnamed: R41.2, R42.1, U16.2 (-)
unnamed: C22.1, R37.2, U17.3 (+)
unnamed: R43.2, R44.1, U17.2 (-)
unnamed: C24.1, R38.2, U18.3 (+)
unnamed: R45.2, R46.1, U18.2 (-)
unnamed: C26.1, R39.2, U19.3 (+)
unnamed: R47.2, R48.1, U19.2 (-)
unnamed: C28.1, R40.2, U20.3 (+)
unnamed: R50.2, R51.1, U20.2 (-)
unnamed: C31.1, R49.2, U21.3 (+)
unnamed: U21.2 (-), U26.3 (RH)
unnamed: C32.1, R52.2, U22.3 (+)
unnamed: U22.2 (-), U27.3 (RH)
unnamed: C33.1, R53.2, U23.3 (+)
unnamed: U23.2 (-), U28.3 (RH)
unnamed: C34.1, R54.2, U24.3 (+)
unnamed: U24.2 (-), U29.3 (RH)
unnamed: C35.1, R55.2, U25.3 (+)
unnamed: U25.2 (-), U30.3 (RH)
unnamed: R56.1, U26.4 (RW)
unnamed: R57.1, U27.4 (RW)
unnamed: R58.1, U28.4 (RW)
unnamed: R59.1, U29.4 (RW)
unnamed: R60.1, U30.4 (RW)
unnamed: U32.3 (RH), U37.2 (-)
unnamed: R71.1, U32.4 (RW)
unnamed: U33.3 (RH), U38.2 (-)
unnamed: R72.1, U33.4 (RW)
unnamed: U34.3 (RH), U39.2 (-)
unnamed: R73.1, U34.4 (RW)
unnamed: U35.3 (RH), U40.2 (-)
unnamed: R74.1, U35.4 (RW)
unnamed: U36.3 (RH), U41.2 (-)
unnamed: R75.1, U36.4 (RW)
unnamed: C46.1, R76.2, U37.3 (+)
unnamed: C47.1, R77.2, U38.3 (+)
unnamed: C48.1, R78.2, U39.3 (+)
unnamed: C49.1, R79.2, U40.3 (+)
unnamed: C50.1, R82.2, U41.3 (+)
unnamed: C53.1, R91.2, U42.3 (+)
unnamed: R80.1, R81.2, U42.2 (-)
unnamed: C55.1, R92.2, U43.3 (+)
unnamed: R83.1, R84.2, U43.2 (-)
unnamed: C57.1, R93.2, U44.3 (+)
unnamed: R85.1, R86.2, U44.2 (-)
unnamed: C59.1, R94.2, U45.3 (+)
unnamed: R87.1, R88.2, U45.2 (-)
unnamed: C60.1, R95.2, U46.3 (+)
unnamed: R89.1, R90.2, U46.2 (-)
unnamed: C61.2, R111.1, U47.3 (+)
unnamed: R96.1, R100.1, U47.2 (-), U47.6
unnamed: R99.1, R100.2, U48.3 (+)
unnamed: C63.2, C70.2, R116.2, U48.2 (-), U48.6
unnamed: C62.2, R112.1, U49.3 (+)
unnamed: R97.1, R103.1, U49.2 (-), U49.6
unnamed: R102.1, R103.2, U50.3 (+)
unnamed: C65.2, C72.2, R117.2, U50.2 (-), U50.6
unnamed: C64.2, R113.1, U51.3 (+)
unnamed: R98.1, R106.1, U51.2 (-), U51.6
unnamed: R105.1, R106.2, U52.3 (+)
unnamed: C67.2, C73.2, R118.2, U52.2 (-), U52.6
unnamed: C66.2, R114.1, U53.3 (+)
unnamed: R101.1, R108.1, U53.2 (-), U53.6
unnamed: R107.1, R108.2, U54.3 (+)
unnamed: C69.2, C74.2, R120.2, U54.2 (-), U54.6
unnamed: C68.2, R115.1, U55.3 (+)
unnamed: R104.1, R110.1, U55.2 (-), U55.6
unnamed: R109.1, R110.2, U56.3 (+)
unnamed: C71.2, C75.2, R122.2, U56.2 (-), U56.6
Ref_Electrode: J1.30, U1.2 (-), U2.2 (-), U3.2 (-), U4.2 (-), U5.2 (-), U57.2 (-), U58.2 (-), U59.2 (-), U60.2 (-), U61.2 (-)
SDI: U26.10 (SDI), U27.10 (SDI), U28.10 (SDI), U29.10 (SDI), U30.10 (SDI), U31.13 (11_MOSI_CTX1), U32.10 (SDI), U33.10 (SDI), U34.10 (SDI), U35.10 (SDI), U36.10 (SDI)
Vss: J2.3, U1.7 (V+), U2.7 (V+), U3.7 (V+), U4.7 (V+), U5.7 (V+), U6.7 (V+), U7.7 (V+), U8.7 (V+), U9.7 (V+), U10.7 (V+), U11.7 (V+), U12.7 (V+), U13.7 (V+), U14.7 (V+), U15.7 (V+), U16.7 (V+), U17.7 (V+), U18.7 (V+), U19.7 (V+), U20.7 (V+), U21.7 (V+), U22.7 (V+), U23.7 (V+), U24.7 (V+), U25.7 (V+), U26.6 (Vdd+), U26.8 (Vlog), U27.6 (Vdd+), U27.8 (Vlog), U28.6 (Vdd+), U28.8 (Vlog), U29.6 (Vdd+), U29.8 (Vlog), U30.6 (Vdd+), U30.8 (Vlog), U32.6 (Vdd+), U32.8 (Vlog), U33.6 (Vdd+), U33.8 (Vlog), U34.6 (Vdd+), U34.8 (Vlog), U35.6 (Vdd+), U35.8 (Vlog), U36.6 (Vdd+), U36.8 (Vlog), U37.7 (V+), U38.7 (V+), U39.7 (V+), U40.7 (V+), U41.7 (V+), U42.7 (V+), U43.7 (V+), U44.7 (V+), U45.7 (V+), U46.7 (V+), U47.7 (V+), U48.7 (V+), U49.7 (V+), U50.7 (V+), U51.7 (V+), U52.7 (V+), U53.7 (V+), U54.7 (V+), U55.7 (V+), U56.7 (V+), U57.7 (V+), U58.7 (V+), U59.7 (V+), U60.7 (V+), U61.7 (V+)

Board: 2 copper layers, 108.0 x 130.8 mm, 273 parts (0 on the bottom side), 207 nets.

## KiCad design Kicad Files/EEG — Seperated/Mother/Mother.kicad_pcb

Board: 2 copper layers, 66.0 x 116.8 mm, 13 parts (0 on the bottom side), 29 nets.

Parts:
Channel1, Channel2, Channel3, Channel4, Channel5, Channel6, Channel7, Channel8, Channel9, Channel10: Conn_01x07_Pin; GoldFingers_1x07_P2.50mm
J1: Conn_01x05_Pin; PinHeader_1x05_P1.27mm_Vertical
J2: Conn_01x02_Pin; PinHeader_1x02_P1.27mm_Vertical
U1: Teensy4.1; Teensy41

Connections:
CKL: Channel1.5, Channel2.5, Channel3.5, Channel4.5, Channel5.5, Channel6.5, Channel7.5, Channel8.5, Channel9.5, Channel10.5, U1.35 (13_SCK_LED)
CS 1: Channel1.6, U1.14 (12_MISO_MQSL)
CS 2: Channel2.6, U1.13 (11_MOSI_CTX1)
CS 3: Channel3.6, U1.12 (10_CS_MQSR)
CS 4: Channel4.6, U1.10 (8_TX2_IN1)
CS 5: Channel5.6, U1.9 (7_RX2_OUT1A)
CS 6: Channel6.6, U1.8 (6_OUT1D)
CS 7: Channel7.6, U1.7 (5_IN2)
CS 8: Channel8.6, U1.6 (4_BCLK2)
CS 9: Channel9.6, U1.5 (3_LRCLK2)
CS 10: Channel10.6, U1.4 (2_OUT2)
GND: Channel1.7, Channel2.7, Channel3.7, Channel4.7, Channel5.7, Channel6.7, Channel7.7, Channel8.7, Channel9.7, Channel10.7, J1.5, U1.1 (GND)
GPIO14_TXD0: J1.1, U1.26 (34_RX8)
GPIO15_RXD0: J1.2, U1.27 (35_TX8)
OUT 1: Channel1.1, U1.36 (14_A0_TX3_SPDIF_OUT)
OUT 2: Channel2.1, U1.37 (15_A1_RX3_SPDIF_IN)
OUT 3: Channel3.1, U1.38 (16_A2_RX4_SCL1)
OUT 4: Channel4.1, U1.39 (17_A3_TX4_SDA1)
OUT 5: Channel5.1, U1.40 (18_A4_SDA)
OUT 6: Channel6.1, U1.41 (19_A5_SCL)
OUT 7: Channel7.1, U1.42 (20_A6_TX5_LRCLK1)
OUT 8: Channel8.1, U1.43 (21_A7_RX5_BCLK1)
OUT 9: Channel9.1, U1.44 (22_A8_CTX1)
OUT 10: Channel10.1, U1.45 (23_A9_CRX1_MCLK1)
SDI: Channel1.4, Channel2.4, Channel3.4, Channel4.4, Channel5.4, Channel6.4, Channel7.4, Channel8.4, Channel9.4, Channel10.4, U1.11 (9_OUT1C)
Vdd: Channel1.3, Channel2.3, Channel3.3, Channel4.3, Channel5.3, Channel6.3, Channel7.3, Channel8.3, Channel9.3, Channel10.3, J1.4
Vin: J2.1, U1.48 (VIN)
Vss: Channel1.2, Channel2.2, Channel3.2, Channel4.2, Channel5.2, Channel6.2, Channel7.2, Channel8.2, Channel9.2, Channel10.2, J1.3
pwr_GND: J2.2, U1.47 (GND)
